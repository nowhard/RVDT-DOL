# Keil uVision project debug.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC841 Analog Devices
  cpu: IRAM(0-0xFF) IROM(0-0xF7FF) XRAM (0-0x7FF) CLOCK(12000000) DPX MODAB2
  output: debug +hex
  c flags: SizeSpeed=1
  group Source Group 1
    ./: debug.c timer3.c adc.c preferences.h watchdog.c START_AD.A51 timer0.c timer2.c dol.c sin_cos_table.h
    ./eeprom/: eeprom.c
    ./proto_uso/: proto_uso.c channels.c
    ./rtos/: timer1.c
    ./pt/: pt.h lc.h lc-switch.h
